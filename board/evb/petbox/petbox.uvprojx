# Keil uVision project petbox.uvprojx, settings and files
target petbox (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\petbox;.\app;.\hal;.\tuya;.\utils;..\..\..\src\mcu\module\cmd_uart;..\..\..\src\mcu\module\at_uart;.\drivers;..\..\..\src\mcu\module\sal;.\drivers
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
    ./: flash_map.h mem_config.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib bee2_adc_lib.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_i2c.c rtl876x_rcc.c rtl876x_tim.c rtl876x_uart.c rtl876x_adc.c
  group app
    ./app/: cmd_task.c app_task.c main.c keyboard.c control_task.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
  group hal
    ../../../src/mcu/module/cmd_uart/: cmd_parse.c cmd_uart.c cmd_uart_dlps.c
    ../../../src/mcu/module/at_uart/: at_uart.c
    ./hal/: control.c
  group utils
    ./utils/: custom_log.c utils.c
  group tuya
    ./tuya/: mcu_api.c protocol.c system.c mcu_api.h protocol.h system.h wifi.h
  group drivers
    ./drivers/: hx711.c battery.c
  group sal
    ../../../src/mcu/module/sal/: sal_gpio.c
