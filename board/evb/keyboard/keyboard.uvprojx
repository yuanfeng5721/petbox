# Keil uVision project keyboard.uvprojx, settings and files
target keyboard (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 wLevel=2
  c misc: --gnu --preinclude app_define.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\ble\privacy;..\keyboard;..\..\..\src\app\keyboard
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group profile
    ../../../src/ble/profile/server/: hids_kb.c bas.c dis.c
    ../../../src/app/keyboard/: ota_service.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_gpio.c rtl876x_keyscan.c
  group app
    ../../../src/app/keyboard/: main.c app_task.c keyboard_app.c keyscan.c key_handler.c keyboard_button.c keyboard_led.c profile_init.c
    ../../../src/ble/privacy/: privacy_mgnt.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
