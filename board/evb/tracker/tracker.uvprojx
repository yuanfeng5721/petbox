# Keil uVision project tracker.uvprojx, settings and files
target tracker (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\tracker\ble;..\tracker;..\..\..\src\iot\include;..\..\..\src\iot\include\exports;..\..\..\src\iot\src\internal_inc;..\..\..\src\iot\platform\at_device\esp8266;..\..\..\src\mcu\module\at_uart;..\..\..\src\iot\platform\at_device\sim7070;..\..\..\src\iot\platform\at_device\sim76xx;..\tracker\protocol;..\tracker\hal;..\..\..\src\mcu\module\cmd_uart;..\tracker\app;..\..\..\src\mcu\module\nv\easyflash\inc;..\..\..\src\mcu\module\nv\hal
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
    ./: mem_config.h flash_map.h
  group lib
    ../../../bin/: ROM.lib gap_bt5.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group app
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ./: main.c
    ./app/: cmd_task.c
  group hal
    ./hal/: rtl876x_hal_bsp.c leds_blink.c rtc.c
    ../../../src/mcu/module/cmd_uart/: cmd_parse.c cmd_uart.c cmd_uart_dlps.c
    ./: custom_log.c
  group protocol
    ./protocol/: readme.txt btlink_protocol_hdlr.c btlink_protocol_util.c btlink_protocol_cmd.c btlink_assem_asc_msg.c btlink_assem_hex_msg.c btlink_trace.c btlink_cmd_rmmi.c
  group ble
    ./ble/: link_mgr.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_rcc.c rtl876x_uart.c rtl876x_gpio.c rtl876x_i2c.c rtl876x_io_dlps.c rtl876x_tim.c
  group iot
    ../../../src/iot/src/: at_client.c at_socket_inf.c at_utils.c network_at_tcp.c network_interface.c string_utils.c utils_list.c utils_ringbuff.c utils_timer.c qcloud_iot_log.c
    ../../../src/iot/platform/os/: HAL_AT_UART_freertos.c HAL_OS_freertos.c HAL_Timer_freertos.c
    ../../../src/iot/include/: config.h
    ../../../src/mcu/module/at_uart/: at_uart.c
    ../../../src/iot/platform/at_device/sim7070/: at_device_sim7070.c
  group nv/port
    ../../../src/mcu/module/nv/easyflash/port/: ef_port.c
  group nv/hal
    ../../../src/mcu/module/nv/hal/: nv.c
  group nv/src
    ../../../src/mcu/module/nv/easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
