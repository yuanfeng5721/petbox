# Keil uVision project adc_oneshot_polling.uvprojx, settings and files
target demo (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 wLevel=2
  c misc: --gnu --bss_threshold=0
  c include: .\;..\..\..\..\..\inc\app;..\..\..\..\..\inc\peripheral;..\..\..\..\..\inc\platform;..\..\..\..\..\inc\platform\cmsis;..\..\..\..\..\inc\os;..\..\..\..\..\inc\bluetooth\gap;..\..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\..\inc\bluetooth\profile;..\..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\..\src\sample\io_sample\ADC\OneShotMode_polling
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../../bin/: bee2_adc_lib.lib gap_utils.lib ROM.lib
  group cmsis
    ../../../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../../../src/mcu/rtl876x/: system_rtl8762c.c overlay_mgr.c
  group peripheral
    ../../../../../src/mcu/peripheral/: rtl876x_adc.c rtl876x_rcc.c
  group app
    ../../../../../src/sample/io_sample/ADC/OneShotMode_Polling/: main.c
